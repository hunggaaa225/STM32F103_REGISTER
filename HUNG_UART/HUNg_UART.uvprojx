# Keil uVision project HUNg_UART.uvprojx, settings and files
target Target_1 (6240000::V6.24::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: HUNg_UART
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F10X_MD
  c include: C:\keilc\arm\pack\Keil\STM32F1xx_DFP\2.4.1\Device\Include;C:\keilc\arm\pack\ARM\CMSIS\6.2.0\CMSIS\Core\Include;..\Driver\HUNG_GPIO;..\Driver\HUNG_RCC
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Source Group 1
    C:/keilc/arm/pack/Keil/STM32F1xx_DFP/2.4.1/Device/Source/: system_stm32f10x.c
    C:/keilc/arm/pack/Keil/STM32F1xx_DFP/2.4.1/Device/Source/ARM/: startup_stm32f10x_md.s
    ./: main.c Uart.c Uart.h
    ../Driver/HUNG_GPIO/: gpio.c gpio.h
    ../Driver/HUNG_RCC/: RCC_Conf.c RCC_conf.h
